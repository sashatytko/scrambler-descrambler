options:
  parameters:
    generate_options: qt_gui
    id: scrambler_descrambler
    output_language: python
    title: Scrambler descrambler
  states: {}

blocks:
- name: inversion_freq_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 4
    label: Inversion freq 0
    rangeType: int
    start: '200'
    step: '1'
    stop: '15000'
    value: '1700'
  states: {}
- name: inversion_freq_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 4
    label: Inversion freq 1
    rangeType: int
    start: '200'
    step: '1'
    stop: '15000'
    value: '2500'
  states: {}
- name: inversion_freq_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 0, 1, 4
    label: Inversion freq 2
    rangeType: int
    start: '200'
    step: '1'
    stop: '15000'
    value: '3500'
  states: {}
- name: inversion_freq_3
  id: variable_qtgui_range
  parameters:
    gui_hint: 4, 0, 1, 4
    label: Inversion freq 3
    rangeType: int
    start: '200'
    step: '1'
    stop: '15000'
    value: '4500'
  states: {}
- name: inversion_variant
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 0, 1, 4
    label: Inversion variant
    label0: Simple inversion
    label1: Split band inversion (2 freq)
    label2: Split band inversion (3 freq)
    label3: Split band inversion (4 freq)
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: abs(inversion_freq_1 - inversion_freq_0)
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: abs(inversion_freq_1 - inversion_freq_0)
    low_cutoff_freq: '0'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: abs(inversion_freq_2 - inversion_freq_1)
    low_cutoff_freq: '0'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: abs(inversion_freq_2 - inversion_freq_1)
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: abs(inversion_freq_3 - inversion_freq_2)
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: abs(inversion_freq_1 - inversion_freq_0)
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: inversion_freq_0
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: samp_rate / 2
    interp: '1'
    low_cutoff_freq: inversion_freq_3
    samp_rate: samp_rate
    type: interp_fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: samp_rate / 2
    low_cutoff_freq: inversion_freq_2
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_4
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: inversion_freq_0
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_5
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: samp_rate / 2
    low_cutoff_freq: inversion_freq_1
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_6
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: inversion_freq_0
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_6_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: inversion_freq_0
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_6_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: samp_rate / 2
    interp: '1'
    low_cutoff_freq: inversion_freq_0
    samp_rate: samp_rate
    type: interp_fir_filter_ccc
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0_1_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0_1_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0_1_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1_0_1_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: inversion_variant
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: inversion_variant
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: scrambler_0.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: scrambler_1.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: scrambler_2.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0_0_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: scrambler_3.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: scrambler_3.wav
    repeat: 'True'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-(samp_rate / 2 + inversion_freq_0)'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_1'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_1'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_2'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_2'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_3'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_1'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-(samp_rate / 2 + inversion_freq_1)'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-(samp_rate / 2 + inversion_freq_2)'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-(samp_rate / 2 + inversion_freq_3)'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_1'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_1'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_2'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-inversion_freq_0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: high_pass_filter_1
  id: high_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '150'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [audio_source_0, '0', high_pass_filter_1, '0']
- [band_pass_filter_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [band_pass_filter_0_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [band_pass_filter_0_0_0, '0', freq_xlating_fir_filter_xxx_1_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', freq_xlating_fir_filter_xxx_1_0_0_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', freq_xlating_fir_filter_xxx_1_0_0_0_0, '0']
- [band_pass_filter_0_0_1, '0', freq_xlating_fir_filter_xxx_1_0_1, '0']
- [band_pass_filter_1, '0', blocks_complex_to_real_0_0_0_0, '0']
- [band_pass_filter_2, '0', blocks_complex_to_real_1_0_0_0_0, '0']
- [band_pass_filter_3, '0', blocks_complex_to_real_1_0_0_0, '0']
- [band_pass_filter_4, '0', blocks_complex_to_real_0_0_0, '0']
- [band_pass_filter_5, '0', blocks_complex_to_real_1_0_0, '0']
- [band_pass_filter_6, '0', blocks_complex_to_real_0_0, '0']
- [band_pass_filter_6_0, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_6_0_0, '0', blocks_complex_to_real_1, '0']
- [blocks_add_xx_0, '0', blocks_selector_0_0, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_xx_0_0, '0', blocks_selector_0_0, '1']
- [blocks_add_xx_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_add_xx_0_0_0, '0', blocks_selector_0_0, '2']
- [blocks_add_xx_0_0_0, '0', blocks_wavfile_sink_0_0_0, '0']
- [blocks_add_xx_0_0_0_0, '0', blocks_selector_0_0, '3']
- [blocks_add_xx_0_0_0_0, '0', blocks_wavfile_sink_0_0_1, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_complex_to_real_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_complex_to_real_0_0_0_0, '0', blocks_add_xx_0_0_0_0, '0']
- [blocks_complex_to_real_1, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_real_1_0, '0', blocks_add_xx_0_0, '1']
- [blocks_complex_to_real_1_0_0, '0', blocks_add_xx_0_0, '2']
- [blocks_complex_to_real_1_0_0_0, '0', blocks_add_xx_0_0_0, '3']
- [blocks_complex_to_real_1_0_0_0_0, '0', blocks_add_xx_0_0_0_0, '4']
- [blocks_complex_to_real_1_0_1, '0', blocks_add_xx_0_0_0, '1']
- [blocks_complex_to_real_1_0_1_0, '0', blocks_add_xx_0_0_0, '2']
- [blocks_complex_to_real_1_0_1_0_0, '0', blocks_add_xx_0_0_0_0, '2']
- [blocks_complex_to_real_1_0_1_0_0_0, '0', blocks_add_xx_0_0_0_0, '3']
- [blocks_complex_to_real_1_0_1_1, '0', blocks_add_xx_0_0_0_0, '1']
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_selector_0, '1', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_selector_0, '1', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [blocks_selector_0, '1', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_selector_0, '2', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [blocks_selector_0, '2', freq_xlating_fir_filter_xxx_0_0_0_0_0, '0']
- [blocks_selector_0, '2', freq_xlating_fir_filter_xxx_0_0_1_0, '0']
- [blocks_selector_0, '2', freq_xlating_fir_filter_xxx_0_1_0, '0']
- [blocks_selector_0, '3', freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0']
- [blocks_selector_0, '3', freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0, '0']
- [blocks_selector_0, '3', freq_xlating_fir_filter_xxx_0_0_0_0_1, '0']
- [blocks_selector_0, '3', freq_xlating_fir_filter_xxx_0_0_1_0_0, '0']
- [blocks_selector_0, '3', freq_xlating_fir_filter_xxx_0_1_0_0, '0']
- [blocks_selector_0_0, '0', audio_sink_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', high_pass_filter_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_6_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', band_pass_filter_6_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', band_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', band_pass_filter_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', band_pass_filter_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0', band_pass_filter_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0, '0', band_pass_filter_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_1, '0', band_pass_filter_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', band_pass_filter_5, '0']
- [freq_xlating_fir_filter_xxx_0_0_1_0, '0', band_pass_filter_3, '0']
- [freq_xlating_fir_filter_xxx_0_0_1_0_0, '0', band_pass_filter_2, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', band_pass_filter_6, '0']
- [freq_xlating_fir_filter_xxx_0_1_0, '0', band_pass_filter_4, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0, '0', band_pass_filter_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_complex_to_real_1_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', blocks_complex_to_real_1_0_1, '0']
- [freq_xlating_fir_filter_xxx_1_0_0, '0', blocks_complex_to_real_1_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_1_0_0_0, '0', blocks_complex_to_real_1_0_1_0_0, '0']
- [freq_xlating_fir_filter_xxx_1_0_0_0_0, '0', blocks_complex_to_real_1_0_1_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_1_0_1, '0', blocks_complex_to_real_1_0_1_1, '0']
- [high_pass_filter_1, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
